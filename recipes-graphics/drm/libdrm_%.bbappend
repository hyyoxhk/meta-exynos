PACKAGECONFIG = "libkms exynos"
