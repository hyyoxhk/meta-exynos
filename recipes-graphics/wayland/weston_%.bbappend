PACKAGECONFIG:append = " fbdev"
