
#CORE_IMAGE_EXTRA_INSTALL

WKS_FILE = "emmc-itop-scp-1GB.wks.in"
